v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/dev/git/magic-dds/lvs/current_steering_dac.sym} 190 -70 0 0 {name=x1}
C {/home/madvlsi/dev/git/magic-dds/xschem/binary_decoder_4bit_lvs.sym} 40 -250 0 0 {name=x2}
C {/home/madvlsi/dev/git/magic-dds/xschem/current_difference_balanced.sym} 420 -210 0 0 {name=x3}
