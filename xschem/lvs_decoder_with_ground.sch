v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {madvlsi/gnd.sym} 140 -170 2 0 {name=l1 lab=GND}
C {madvlsi/vdd.sym} 100 -170 0 0 {name=l2 lab=VDD}
C {/home/madvlsi/dev/git/magic-dds/xschem/binary_decoder_4bit_lvs.sym} 50 -50 0 0 {name=x1}
